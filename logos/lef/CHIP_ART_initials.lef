VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_initials
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_initials 0.000 0.000 ;
  SIZE 9.600 BY 9.600 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 0.000 9.000 0.600 9.600 ;
      RECT 0.000 8.400 0.600 9.000 ;
      RECT 0.000 7.800 0.600 8.400 ;
      RECT 0.000 7.200 0.600 7.800 ;
      RECT 0.000 6.600 0.600 7.200 ;
      RECT 0.000 6.000 0.600 6.600 ;
      RECT 0.000 5.400 0.600 6.000 ;
      RECT 0.000 4.800 0.600 5.400 ;
      RECT 4.800 4.800 5.400 5.400 ;
      RECT 0.000 4.200 0.600 4.800 ;
      RECT 4.200 4.200 4.800 4.800 ;
      RECT 0.000 3.600 0.600 4.200 ;
      RECT 3.600 3.600 4.200 4.200 ;
      RECT 0.000 3.000 0.600 3.600 ;
      RECT 3.000 3.000 3.600 3.600 ;
      RECT 0.000 2.400 0.600 3.000 ;
      RECT 2.400 2.400 3.000 3.000 ;
      RECT 0.000 1.800 0.600 2.400 ;
      RECT 1.800 1.800 2.400 2.400 ;
      RECT 0.000 1.200 0.600 1.800 ;
      RECT 1.200 1.200 1.800 1.800 ;
      RECT 4.800 1.200 5.400 1.800 ;
      RECT 0.000 0.600 1.200 1.200 ;
      RECT 4.800 0.600 5.400 1.200 ;
      RECT 0.000 0.000 9.600 0.600 ;
      RECT 4.500 4.500 5.100 5.100 ;
      RECT 3.900 3.900 4.500 4.500 ;
      RECT 3.300 3.300 3.900 3.900 ;
      RECT 2.700 2.700 3.300 3.300 ;
      RECT 2.100 2.100 2.700 2.700 ;
      RECT 1.500 1.500 2.100 2.100 ;
      RECT 0.900 0.900 1.500 1.500 ;
  END
END CHIP_ART_initials

END LIBRARY
