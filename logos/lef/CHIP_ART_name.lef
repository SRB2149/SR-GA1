VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_name
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_name 0.000 0.000 ;
  SIZE 91.200 BY 12.600 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 0.000 12.000 28.800 12.600 ;
      RECT 30.000 12.000 30.600 12.600 ;
      RECT 31.200 12.000 33.000 12.600 ;
      RECT 34.200 12.000 91.200 12.600 ;
      RECT 0.000 11.400 0.600 12.000 ;
      RECT 27.600 11.400 28.200 12.000 ;
      RECT 29.400 11.400 30.600 12.000 ;
      RECT 31.200 11.400 31.800 12.000 ;
      RECT 32.400 11.400 33.000 12.000 ;
      RECT 34.200 11.400 35.400 12.000 ;
      RECT 36.600 11.400 37.800 12.000 ;
      RECT 39.000 11.400 40.200 12.000 ;
      RECT 40.800 11.400 41.400 12.000 ;
      RECT 42.000 11.400 42.600 12.000 ;
      RECT 43.200 11.400 44.400 12.000 ;
      RECT 45.600 11.400 46.200 12.000 ;
      RECT 46.800 11.400 47.400 12.000 ;
      RECT 48.600 11.400 49.800 12.000 ;
      RECT 51.000 11.400 51.600 12.000 ;
      RECT 52.200 11.400 52.800 12.000 ;
      RECT 54.000 11.400 54.600 12.000 ;
      RECT 55.800 11.400 57.600 12.000 ;
      RECT 90.600 11.400 91.200 12.000 ;
      RECT 0.000 10.800 0.600 11.400 ;
      RECT 2.400 10.800 4.800 11.400 ;
      RECT 5.400 10.800 8.400 11.400 ;
      RECT 9.600 10.800 11.400 11.400 ;
      RECT 12.600 10.800 13.200 11.400 ;
      RECT 15.000 10.800 15.600 11.400 ;
      RECT 16.200 10.800 16.800 11.400 ;
      RECT 19.800 10.800 22.800 11.400 ;
      RECT 23.400 10.800 24.000 11.400 ;
      RECT 25.800 10.800 26.400 11.400 ;
      RECT 27.600 10.800 28.200 11.400 ;
      RECT 30.000 10.800 30.600 11.400 ;
      RECT 31.200 10.800 31.800 11.400 ;
      RECT 32.400 10.800 33.000 11.400 ;
      RECT 34.200 10.800 57.600 11.400 ;
      RECT 58.800 10.800 61.200 11.400 ;
      RECT 90.600 10.800 91.200 11.400 ;
      RECT 0.000 10.200 0.600 10.800 ;
      RECT 1.800 10.200 2.400 10.800 ;
      RECT 6.600 10.200 7.200 10.800 ;
      RECT 9.000 10.200 9.600 10.800 ;
      RECT 11.400 10.200 12.000 10.800 ;
      RECT 12.600 10.200 13.800 10.800 ;
      RECT 15.000 10.200 15.600 10.800 ;
      RECT 16.200 10.200 16.800 10.800 ;
      RECT 19.800 10.200 20.400 10.800 ;
      RECT 23.400 10.200 24.000 10.800 ;
      RECT 25.800 10.200 26.400 10.800 ;
      RECT 27.600 10.200 28.200 10.800 ;
      RECT 30.000 10.200 30.600 10.800 ;
      RECT 31.200 10.200 31.800 10.800 ;
      RECT 32.400 10.200 33.000 10.800 ;
      RECT 57.000 10.200 57.600 10.800 ;
      RECT 58.800 10.200 59.400 10.800 ;
      RECT 87.600 10.200 88.200 10.800 ;
      RECT 90.600 10.200 91.200 10.800 ;
      RECT 0.000 9.600 0.600 10.200 ;
      RECT 1.800 9.600 2.400 10.200 ;
      RECT 6.600 9.600 7.200 10.200 ;
      RECT 9.000 9.600 9.600 10.200 ;
      RECT 11.400 9.600 12.000 10.200 ;
      RECT 12.600 9.600 13.200 10.200 ;
      RECT 13.800 9.600 14.400 10.200 ;
      RECT 15.000 9.600 15.600 10.200 ;
      RECT 16.200 9.600 16.800 10.200 ;
      RECT 19.800 9.600 20.400 10.200 ;
      RECT 24.000 9.600 24.600 10.200 ;
      RECT 25.200 9.600 25.800 10.200 ;
      RECT 27.600 9.600 28.200 10.200 ;
      RECT 30.000 9.600 30.600 10.200 ;
      RECT 31.200 9.600 33.000 10.200 ;
      RECT 57.000 9.600 57.600 10.200 ;
      RECT 58.800 9.600 59.400 10.200 ;
      RECT 61.200 9.600 61.800 10.200 ;
      RECT 65.400 9.600 66.000 10.200 ;
      RECT 67.200 9.600 68.400 10.200 ;
      RECT 87.600 9.600 88.200 10.200 ;
      RECT 90.600 9.600 91.200 10.200 ;
      RECT 0.000 9.000 0.600 9.600 ;
      RECT 2.400 9.000 4.200 9.600 ;
      RECT 6.600 9.000 7.200 9.600 ;
      RECT 9.000 9.000 12.000 9.600 ;
      RECT 12.600 9.000 13.200 9.600 ;
      RECT 13.800 9.000 14.400 9.600 ;
      RECT 15.000 9.000 15.600 9.600 ;
      RECT 16.200 9.000 16.800 9.600 ;
      RECT 19.800 9.000 21.600 9.600 ;
      RECT 24.000 9.000 24.600 9.600 ;
      RECT 25.200 9.000 25.800 9.600 ;
      RECT 27.600 9.000 28.200 9.600 ;
      RECT 57.000 9.000 57.600 9.600 ;
      RECT 58.800 9.000 60.600 9.600 ;
      RECT 63.000 9.000 64.200 9.600 ;
      RECT 66.600 9.000 67.200 9.600 ;
      RECT 70.800 9.000 72.000 9.600 ;
      RECT 73.200 9.000 74.400 9.600 ;
      RECT 75.600 9.000 76.200 9.600 ;
      RECT 76.800 9.000 77.400 9.600 ;
      RECT 79.200 9.000 80.400 9.600 ;
      RECT 82.200 9.000 83.400 9.600 ;
      RECT 85.200 9.000 86.400 9.600 ;
      RECT 87.600 9.000 88.800 9.600 ;
      RECT 90.600 9.000 91.200 9.600 ;
      RECT 0.000 8.400 0.600 9.000 ;
      RECT 4.200 8.400 4.800 9.000 ;
      RECT 6.600 8.400 7.200 9.000 ;
      RECT 9.000 8.400 9.600 9.000 ;
      RECT 11.400 8.400 12.000 9.000 ;
      RECT 12.600 8.400 13.200 9.000 ;
      RECT 13.800 8.400 14.400 9.000 ;
      RECT 15.000 8.400 15.600 9.000 ;
      RECT 16.200 8.400 16.800 9.000 ;
      RECT 19.800 8.400 20.400 9.000 ;
      RECT 24.600 8.400 25.200 9.000 ;
      RECT 27.600 8.400 28.200 9.000 ;
      RECT 29.400 8.400 33.000 9.000 ;
      RECT 34.200 8.400 34.800 9.000 ;
      RECT 54.600 8.400 55.200 9.000 ;
      RECT 57.000 8.400 57.600 9.000 ;
      RECT 58.800 8.400 59.400 9.000 ;
      RECT 61.200 8.400 61.800 9.000 ;
      RECT 62.400 8.400 63.000 9.000 ;
      RECT 64.200 8.400 64.800 9.000 ;
      RECT 65.400 8.400 66.000 9.000 ;
      RECT 67.200 8.400 67.800 9.000 ;
      RECT 70.200 8.400 70.800 9.000 ;
      RECT 72.600 8.400 73.200 9.000 ;
      RECT 74.400 8.400 75.000 9.000 ;
      RECT 75.600 8.400 76.800 9.000 ;
      RECT 77.400 8.400 78.000 9.000 ;
      RECT 78.600 8.400 79.200 9.000 ;
      RECT 80.400 8.400 81.000 9.000 ;
      RECT 81.600 8.400 82.200 9.000 ;
      RECT 83.400 8.400 84.000 9.000 ;
      RECT 84.600 8.400 85.200 9.000 ;
      RECT 86.400 8.400 87.000 9.000 ;
      RECT 87.600 8.400 88.200 9.000 ;
      RECT 90.600 8.400 91.200 9.000 ;
      RECT 0.000 7.800 0.600 8.400 ;
      RECT 4.200 7.800 4.800 8.400 ;
      RECT 6.600 7.800 7.200 8.400 ;
      RECT 9.000 7.800 9.600 8.400 ;
      RECT 11.400 7.800 12.000 8.400 ;
      RECT 12.600 7.800 13.200 8.400 ;
      RECT 14.400 7.800 15.600 8.400 ;
      RECT 16.200 7.800 16.800 8.400 ;
      RECT 19.800 7.800 20.400 8.400 ;
      RECT 24.600 7.800 25.200 8.400 ;
      RECT 27.600 7.800 28.200 8.400 ;
      RECT 29.400 7.800 30.000 8.400 ;
      RECT 33.600 7.800 34.200 8.400 ;
      RECT 37.800 7.800 39.000 8.400 ;
      RECT 55.200 7.800 55.800 8.400 ;
      RECT 57.000 7.800 57.600 8.400 ;
      RECT 58.800 7.800 59.400 8.400 ;
      RECT 61.200 7.800 61.800 8.400 ;
      RECT 62.400 7.800 63.000 8.400 ;
      RECT 64.200 7.800 64.800 8.400 ;
      RECT 65.400 7.800 66.000 8.400 ;
      RECT 67.800 7.800 68.400 8.400 ;
      RECT 70.200 7.800 70.800 8.400 ;
      RECT 72.600 7.800 73.200 8.400 ;
      RECT 74.400 7.800 75.000 8.400 ;
      RECT 75.600 7.800 76.200 8.400 ;
      RECT 78.600 7.800 79.200 8.400 ;
      RECT 80.400 7.800 81.000 8.400 ;
      RECT 81.600 7.800 82.200 8.400 ;
      RECT 83.400 7.800 84.000 8.400 ;
      RECT 84.600 7.800 85.200 8.400 ;
      RECT 86.400 7.800 87.000 8.400 ;
      RECT 87.600 7.800 88.200 8.400 ;
      RECT 90.600 7.800 91.200 8.400 ;
      RECT 0.000 7.200 0.600 7.800 ;
      RECT 1.800 7.200 4.200 7.800 ;
      RECT 6.600 7.200 7.200 7.800 ;
      RECT 9.000 7.200 9.600 7.800 ;
      RECT 11.400 7.200 12.000 7.800 ;
      RECT 12.600 7.200 13.200 7.800 ;
      RECT 15.000 7.200 15.600 7.800 ;
      RECT 16.200 7.200 19.200 7.800 ;
      RECT 19.800 7.200 22.800 7.800 ;
      RECT 24.600 7.200 25.200 7.800 ;
      RECT 27.600 7.200 28.200 7.800 ;
      RECT 30.000 7.200 30.600 7.800 ;
      RECT 33.600 7.200 34.200 7.800 ;
      RECT 37.800 7.200 38.400 7.800 ;
      RECT 39.000 7.200 39.600 7.800 ;
      RECT 55.200 7.200 55.800 7.800 ;
      RECT 57.000 7.200 57.600 7.800 ;
      RECT 58.800 7.200 59.400 7.800 ;
      RECT 61.200 7.200 61.800 7.800 ;
      RECT 62.400 7.200 63.000 7.800 ;
      RECT 64.200 7.200 64.800 7.800 ;
      RECT 65.400 7.200 66.000 7.800 ;
      RECT 66.600 7.200 67.800 7.800 ;
      RECT 70.800 7.200 72.000 7.800 ;
      RECT 73.200 7.200 74.400 7.800 ;
      RECT 75.600 7.200 76.200 7.800 ;
      RECT 79.200 7.200 80.400 7.800 ;
      RECT 81.600 7.200 82.200 7.800 ;
      RECT 83.400 7.200 84.000 7.800 ;
      RECT 85.200 7.200 87.000 7.800 ;
      RECT 88.200 7.200 89.400 7.800 ;
      RECT 90.600 7.200 91.200 7.800 ;
      RECT 0.000 6.600 0.600 7.200 ;
      RECT 27.600 6.600 28.200 7.200 ;
      RECT 30.600 6.600 31.200 7.200 ;
      RECT 33.600 6.600 34.200 7.200 ;
      RECT 35.400 6.600 37.200 7.200 ;
      RECT 37.800 6.600 38.400 7.200 ;
      RECT 39.000 6.600 39.600 7.200 ;
      RECT 42.000 6.600 43.800 7.200 ;
      RECT 49.200 6.600 51.000 7.200 ;
      RECT 52.200 6.600 54.000 7.200 ;
      RECT 55.200 6.600 55.800 7.200 ;
      RECT 57.000 6.600 57.600 7.200 ;
      RECT 90.600 6.600 91.200 7.200 ;
      RECT 0.000 6.000 0.600 6.600 ;
      RECT 1.200 6.000 27.000 6.600 ;
      RECT 27.600 6.000 28.200 6.600 ;
      RECT 31.200 6.000 31.800 6.600 ;
      RECT 33.600 6.000 34.200 6.600 ;
      RECT 36.600 6.000 37.200 6.600 ;
      RECT 40.200 6.000 40.800 6.600 ;
      RECT 43.200 6.000 43.800 6.600 ;
      RECT 49.200 6.000 49.800 6.600 ;
      RECT 50.400 6.000 51.000 6.600 ;
      RECT 53.400 6.000 54.000 6.600 ;
      RECT 55.200 6.000 55.800 6.600 ;
      RECT 57.000 6.000 57.600 6.600 ;
      RECT 58.200 6.000 90.000 6.600 ;
      RECT 90.600 6.000 91.200 6.600 ;
      RECT 0.000 5.400 0.600 6.000 ;
      RECT 27.600 5.400 28.200 6.000 ;
      RECT 30.600 5.400 31.200 6.000 ;
      RECT 33.600 5.400 34.200 6.000 ;
      RECT 35.400 5.400 37.200 6.000 ;
      RECT 39.600 5.400 41.400 6.000 ;
      RECT 42.000 5.400 43.800 6.000 ;
      RECT 44.400 5.400 45.600 6.000 ;
      RECT 46.800 5.400 48.600 6.000 ;
      RECT 49.200 5.400 49.800 6.000 ;
      RECT 50.400 5.400 51.000 6.000 ;
      RECT 53.400 5.400 54.000 6.000 ;
      RECT 55.200 5.400 55.800 6.000 ;
      RECT 57.000 5.400 57.600 6.000 ;
      RECT 90.600 5.400 91.200 6.000 ;
      RECT 0.000 4.800 0.600 5.400 ;
      RECT 1.800 4.800 4.200 5.400 ;
      RECT 9.000 4.800 11.400 5.400 ;
      RECT 13.200 4.800 15.000 5.400 ;
      RECT 16.800 4.800 18.600 5.400 ;
      RECT 19.800 4.800 22.800 5.400 ;
      RECT 23.400 4.800 24.000 5.400 ;
      RECT 25.800 4.800 26.400 5.400 ;
      RECT 27.600 4.800 28.200 5.400 ;
      RECT 30.000 4.800 30.600 5.400 ;
      RECT 33.600 4.800 34.200 5.400 ;
      RECT 35.400 4.800 36.000 5.400 ;
      RECT 40.200 4.800 40.800 5.400 ;
      RECT 42.000 4.800 42.600 5.400 ;
      RECT 44.400 4.800 45.000 5.400 ;
      RECT 45.600 4.800 46.200 5.400 ;
      RECT 49.200 4.800 49.800 5.400 ;
      RECT 50.400 4.800 51.000 5.400 ;
      RECT 53.400 4.800 54.000 5.400 ;
      RECT 55.200 4.800 55.800 5.400 ;
      RECT 57.000 4.800 57.600 5.400 ;
      RECT 0.000 4.200 0.600 4.800 ;
      RECT 1.800 4.200 2.400 4.800 ;
      RECT 4.200 4.200 4.800 4.800 ;
      RECT 9.000 4.200 9.600 4.800 ;
      RECT 11.400 4.200 12.000 4.800 ;
      RECT 12.600 4.200 13.200 4.800 ;
      RECT 15.000 4.200 15.600 4.800 ;
      RECT 16.200 4.200 16.800 4.800 ;
      RECT 18.600 4.200 19.200 4.800 ;
      RECT 21.000 4.200 21.600 4.800 ;
      RECT 23.400 4.200 24.000 4.800 ;
      RECT 25.800 4.200 26.400 4.800 ;
      RECT 27.600 4.200 28.200 4.800 ;
      RECT 29.400 4.200 30.000 4.800 ;
      RECT 33.600 4.200 34.200 4.800 ;
      RECT 35.400 4.200 37.200 4.800 ;
      RECT 42.000 4.200 43.800 4.800 ;
      RECT 44.400 4.200 45.000 4.800 ;
      RECT 45.600 4.200 46.200 4.800 ;
      RECT 49.200 4.200 51.000 4.800 ;
      RECT 51.600 4.200 52.200 4.800 ;
      RECT 53.400 4.200 54.000 4.800 ;
      RECT 55.200 4.200 55.800 4.800 ;
      RECT 57.000 4.200 57.600 4.800 ;
      RECT 0.000 3.600 0.600 4.200 ;
      RECT 1.800 3.600 2.400 4.200 ;
      RECT 4.200 3.600 4.800 4.200 ;
      RECT 9.000 3.600 9.600 4.200 ;
      RECT 11.400 3.600 12.000 4.200 ;
      RECT 12.600 3.600 13.200 4.200 ;
      RECT 15.000 3.600 15.600 4.200 ;
      RECT 16.200 3.600 16.800 4.200 ;
      RECT 18.600 3.600 19.200 4.200 ;
      RECT 21.000 3.600 21.600 4.200 ;
      RECT 23.400 3.600 24.000 4.200 ;
      RECT 25.800 3.600 26.400 4.200 ;
      RECT 27.600 3.600 28.200 4.200 ;
      RECT 29.400 3.600 33.000 4.200 ;
      RECT 34.200 3.600 34.800 4.200 ;
      RECT 54.600 3.600 55.200 4.200 ;
      RECT 57.000 3.600 57.600 4.200 ;
      RECT 68.400 3.600 69.600 4.200 ;
      RECT 77.400 3.600 79.800 4.200 ;
      RECT 81.600 3.600 83.400 4.200 ;
      RECT 84.600 3.600 87.000 4.200 ;
      RECT 88.800 3.600 90.600 4.200 ;
      RECT 0.000 3.000 0.600 3.600 ;
      RECT 1.800 3.000 4.200 3.600 ;
      RECT 9.000 3.000 11.400 3.600 ;
      RECT 12.600 3.000 13.200 3.600 ;
      RECT 15.000 3.000 15.600 3.600 ;
      RECT 16.200 3.000 16.800 3.600 ;
      RECT 18.600 3.000 19.200 3.600 ;
      RECT 21.000 3.000 21.600 3.600 ;
      RECT 23.400 3.000 26.400 3.600 ;
      RECT 27.600 3.000 28.200 3.600 ;
      RECT 57.000 3.000 57.600 3.600 ;
      RECT 59.400 3.000 60.600 3.600 ;
      RECT 62.400 3.000 63.600 3.600 ;
      RECT 64.800 3.000 65.400 3.600 ;
      RECT 66.600 3.000 67.200 3.600 ;
      RECT 67.800 3.000 68.400 3.600 ;
      RECT 79.800 3.000 80.400 3.600 ;
      RECT 81.000 3.000 81.600 3.600 ;
      RECT 83.400 3.000 84.000 3.600 ;
      RECT 87.000 3.000 87.600 3.600 ;
      RECT 88.200 3.000 88.800 3.600 ;
      RECT 0.000 2.400 0.600 3.000 ;
      RECT 1.800 2.400 2.400 3.000 ;
      RECT 4.200 2.400 4.800 3.000 ;
      RECT 9.000 2.400 9.600 3.000 ;
      RECT 11.400 2.400 12.000 3.000 ;
      RECT 12.600 2.400 13.200 3.000 ;
      RECT 15.000 2.400 15.600 3.000 ;
      RECT 16.200 2.400 16.800 3.000 ;
      RECT 18.600 2.400 19.200 3.000 ;
      RECT 21.000 2.400 21.600 3.000 ;
      RECT 23.400 2.400 24.000 3.000 ;
      RECT 25.800 2.400 26.400 3.000 ;
      RECT 27.600 2.400 28.200 3.000 ;
      RECT 31.200 2.400 31.800 3.000 ;
      RECT 57.000 2.400 57.600 3.000 ;
      RECT 58.800 2.400 59.400 3.000 ;
      RECT 60.600 2.400 61.200 3.000 ;
      RECT 61.800 2.400 62.400 3.000 ;
      RECT 63.600 2.400 64.200 3.000 ;
      RECT 64.800 2.400 65.400 3.000 ;
      RECT 66.600 2.400 67.200 3.000 ;
      RECT 68.400 2.400 69.000 3.000 ;
      RECT 79.800 2.400 80.400 3.000 ;
      RECT 81.000 2.400 81.600 3.000 ;
      RECT 83.400 2.400 84.000 3.000 ;
      RECT 87.000 2.400 87.600 3.000 ;
      RECT 88.200 2.400 88.800 3.000 ;
      RECT 0.000 1.800 0.600 2.400 ;
      RECT 1.800 1.800 2.400 2.400 ;
      RECT 4.200 1.800 4.800 2.400 ;
      RECT 9.000 1.800 9.600 2.400 ;
      RECT 11.400 1.800 12.000 2.400 ;
      RECT 12.600 1.800 13.200 2.400 ;
      RECT 15.000 1.800 15.600 2.400 ;
      RECT 16.200 1.800 16.800 2.400 ;
      RECT 18.600 1.800 19.200 2.400 ;
      RECT 21.000 1.800 21.600 2.400 ;
      RECT 23.400 1.800 24.000 2.400 ;
      RECT 25.800 1.800 26.400 2.400 ;
      RECT 27.600 1.800 28.200 2.400 ;
      RECT 30.600 1.800 31.800 2.400 ;
      RECT 57.000 1.800 57.600 2.400 ;
      RECT 58.800 1.800 59.400 2.400 ;
      RECT 60.600 1.800 61.200 2.400 ;
      RECT 61.800 1.800 62.400 2.400 ;
      RECT 63.600 1.800 64.200 2.400 ;
      RECT 64.800 1.800 65.400 2.400 ;
      RECT 66.600 1.800 67.200 2.400 ;
      RECT 69.000 1.800 69.600 2.400 ;
      RECT 78.000 1.800 79.800 2.400 ;
      RECT 81.000 1.800 81.600 2.400 ;
      RECT 83.400 1.800 84.000 2.400 ;
      RECT 85.200 1.800 87.000 2.400 ;
      RECT 88.200 1.800 90.600 2.400 ;
      RECT 0.000 1.200 0.600 1.800 ;
      RECT 1.800 1.200 2.400 1.800 ;
      RECT 4.200 1.200 4.800 1.800 ;
      RECT 5.400 1.200 6.000 1.800 ;
      RECT 9.000 1.200 11.400 1.800 ;
      RECT 13.200 1.200 15.000 1.800 ;
      RECT 16.800 1.200 18.600 1.800 ;
      RECT 21.000 1.200 21.600 1.800 ;
      RECT 23.400 1.200 24.000 1.800 ;
      RECT 25.800 1.200 26.400 1.800 ;
      RECT 27.600 1.200 28.200 1.800 ;
      RECT 31.200 1.200 31.800 1.800 ;
      RECT 32.400 1.200 57.600 1.800 ;
      RECT 59.400 1.200 60.600 1.800 ;
      RECT 61.800 1.200 63.600 1.800 ;
      RECT 65.400 1.200 66.600 1.800 ;
      RECT 67.800 1.200 69.000 1.800 ;
      RECT 70.200 1.200 70.800 1.800 ;
      RECT 77.400 1.200 78.000 1.800 ;
      RECT 81.000 1.200 81.600 1.800 ;
      RECT 83.400 1.200 84.000 1.800 ;
      RECT 84.600 1.200 85.200 1.800 ;
      RECT 88.200 1.200 88.800 1.800 ;
      RECT 90.600 1.200 91.200 1.800 ;
      RECT 0.000 0.600 0.600 1.200 ;
      RECT 27.600 0.600 28.200 1.200 ;
      RECT 31.200 0.600 31.800 1.200 ;
      RECT 32.400 0.600 33.600 1.200 ;
      RECT 34.200 0.600 34.800 1.200 ;
      RECT 35.400 0.600 36.000 1.200 ;
      RECT 37.200 0.600 37.800 1.200 ;
      RECT 39.600 0.600 40.200 1.200 ;
      RECT 43.200 0.600 43.800 1.200 ;
      RECT 48.600 0.600 49.200 1.200 ;
      RECT 57.000 0.600 57.600 1.200 ;
      RECT 61.800 0.600 62.400 1.200 ;
      RECT 77.400 0.600 78.000 1.200 ;
      RECT 81.000 0.600 81.600 1.200 ;
      RECT 83.400 0.600 84.000 1.200 ;
      RECT 84.600 0.600 85.200 1.200 ;
      RECT 88.200 0.600 88.800 1.200 ;
      RECT 90.600 0.600 91.200 1.200 ;
      RECT 0.000 0.000 30.600 0.600 ;
      RECT 31.200 0.000 31.800 0.600 ;
      RECT 32.400 0.000 61.200 0.600 ;
      RECT 61.800 0.000 62.400 0.600 ;
      RECT 63.000 0.000 76.200 0.600 ;
      RECT 77.400 0.000 80.400 0.600 ;
      RECT 81.600 0.000 83.400 0.600 ;
      RECT 84.600 0.000 87.600 0.600 ;
      RECT 88.800 0.000 90.600 0.600 ;
      RECT 2.100 10.500 2.700 11.100 ;
      RECT 9.300 10.500 9.900 11.100 ;
      RECT 11.100 10.500 11.700 11.100 ;
      RECT 13.500 9.900 14.100 10.500 ;
      RECT 23.700 9.900 24.300 10.500 ;
      RECT 25.500 9.900 26.100 10.500 ;
      RECT 2.100 9.300 2.700 9.900 ;
      RECT 66.900 9.300 67.500 9.900 ;
      RECT 3.900 8.700 4.500 9.300 ;
      RECT 24.300 8.700 24.900 9.300 ;
      RECT 24.900 8.700 25.500 9.300 ;
      RECT 62.700 8.700 63.300 9.300 ;
      RECT 63.900 8.700 64.500 9.300 ;
      RECT 66.900 8.700 67.500 9.300 ;
      RECT 70.500 8.700 71.100 9.300 ;
      RECT 72.900 8.700 73.500 9.300 ;
      RECT 74.100 8.700 74.700 9.300 ;
      RECT 76.500 8.700 77.100 9.300 ;
      RECT 77.100 8.700 77.700 9.300 ;
      RECT 78.900 8.700 79.500 9.300 ;
      RECT 80.100 8.700 80.700 9.300 ;
      RECT 81.900 8.700 82.500 9.300 ;
      RECT 83.100 8.700 83.700 9.300 ;
      RECT 84.900 8.700 85.500 9.300 ;
      RECT 86.100 8.700 86.700 9.300 ;
      RECT 14.100 8.100 14.700 8.700 ;
      RECT 33.900 8.100 34.500 8.700 ;
      RECT 54.900 8.100 55.500 8.700 ;
      RECT 67.500 8.100 68.100 8.700 ;
      RECT 3.900 7.500 4.500 8.100 ;
      RECT 29.700 7.500 30.300 8.100 ;
      RECT 38.700 7.500 39.300 8.100 ;
      RECT 67.500 7.500 68.100 8.100 ;
      RECT 70.500 7.500 71.100 8.100 ;
      RECT 72.900 7.500 73.500 8.100 ;
      RECT 74.100 7.500 74.700 8.100 ;
      RECT 78.900 7.500 79.500 8.100 ;
      RECT 80.100 7.500 80.700 8.100 ;
      RECT 84.900 7.500 85.500 8.100 ;
      RECT 87.900 7.500 88.500 8.100 ;
      RECT 30.300 6.900 30.900 7.500 ;
      RECT 30.900 6.300 31.500 6.900 ;
      RECT 30.900 5.700 31.500 6.300 ;
      RECT 30.300 5.100 30.900 5.700 ;
      RECT 45.300 5.100 45.900 5.700 ;
      RECT 3.900 4.500 4.500 5.100 ;
      RECT 11.100 4.500 11.700 5.100 ;
      RECT 12.900 4.500 13.500 5.100 ;
      RECT 14.700 4.500 15.300 5.100 ;
      RECT 16.500 4.500 17.100 5.100 ;
      RECT 18.300 4.500 18.900 5.100 ;
      RECT 29.700 4.500 30.300 5.100 ;
      RECT 33.900 3.900 34.500 4.500 ;
      RECT 54.900 3.900 55.500 4.500 ;
      RECT 3.900 3.300 4.500 3.900 ;
      RECT 11.100 3.300 11.700 3.900 ;
      RECT 68.100 3.300 68.700 3.900 ;
      RECT 79.500 3.300 80.100 3.900 ;
      RECT 81.300 3.300 81.900 3.900 ;
      RECT 83.100 3.300 83.700 3.900 ;
      RECT 86.700 3.300 87.300 3.900 ;
      RECT 88.500 3.300 89.100 3.900 ;
      RECT 3.900 2.700 4.500 3.300 ;
      RECT 11.100 2.700 11.700 3.300 ;
      RECT 59.100 2.700 59.700 3.300 ;
      RECT 60.300 2.700 60.900 3.300 ;
      RECT 62.100 2.700 62.700 3.300 ;
      RECT 63.300 2.700 63.900 3.300 ;
      RECT 68.100 2.700 68.700 3.300 ;
      RECT 68.700 2.100 69.300 2.700 ;
      RECT 79.500 2.100 80.100 2.700 ;
      RECT 86.700 2.100 87.300 2.700 ;
      RECT 11.100 1.500 11.700 2.100 ;
      RECT 12.900 1.500 13.500 2.100 ;
      RECT 14.700 1.500 15.300 2.100 ;
      RECT 16.500 1.500 17.100 2.100 ;
      RECT 18.300 1.500 18.900 2.100 ;
      RECT 59.100 1.500 59.700 2.100 ;
      RECT 60.300 1.500 60.900 2.100 ;
      RECT 63.300 1.500 63.900 2.100 ;
      RECT 65.100 1.500 65.700 2.100 ;
      RECT 66.300 1.500 66.900 2.100 ;
      RECT 68.700 1.500 69.300 2.100 ;
      RECT 77.700 1.500 78.300 2.100 ;
      RECT 84.900 1.500 85.500 2.100 ;
      RECT 90.300 1.500 90.900 2.100 ;
      RECT 81.300 0.300 81.900 0.900 ;
      RECT 83.100 0.300 83.700 0.900 ;
      RECT 88.500 0.300 89.100 0.900 ;
      RECT 90.300 0.300 90.900 0.900 ;
  END
END CHIP_ART_name

END LIBRARY
