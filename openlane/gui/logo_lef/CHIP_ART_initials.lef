VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_initials
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_initials 0.000 0.000 ;
  SIZE 24.000 BY 12.600 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 4.200 12.000 9.000 12.600 ;
      RECT 11.400 12.000 16.200 12.600 ;
      RECT 18.600 12.000 23.400 12.600 ;
      RECT 3.600 11.400 6.000 12.000 ;
      RECT 10.800 11.400 13.200 12.000 ;
      RECT 16.200 11.400 16.800 12.000 ;
      RECT 18.000 11.400 20.400 12.000 ;
      RECT 23.400 11.400 24.000 12.000 ;
      RECT 3.600 10.800 6.000 11.400 ;
      RECT 10.800 10.800 13.200 11.400 ;
      RECT 16.200 10.800 16.800 11.400 ;
      RECT 18.000 10.800 20.400 11.400 ;
      RECT 23.400 10.800 24.000 11.400 ;
      RECT 3.000 10.200 5.400 10.800 ;
      RECT 10.200 10.200 12.600 10.800 ;
      RECT 15.600 10.200 16.200 10.800 ;
      RECT 17.400 10.200 19.800 10.800 ;
      RECT 22.800 10.200 23.400 10.800 ;
      RECT 3.000 9.600 5.400 10.200 ;
      RECT 10.200 9.600 12.600 10.200 ;
      RECT 15.600 9.600 16.200 10.200 ;
      RECT 17.400 9.600 19.800 10.200 ;
      RECT 22.800 9.600 23.400 10.200 ;
      RECT 2.400 9.000 4.800 9.600 ;
      RECT 9.600 9.000 12.600 9.600 ;
      RECT 15.000 9.000 15.600 9.600 ;
      RECT 16.800 9.000 19.800 9.600 ;
      RECT 22.200 9.000 22.800 9.600 ;
      RECT 2.400 8.400 4.800 9.000 ;
      RECT 9.600 8.400 12.000 9.000 ;
      RECT 15.000 8.400 15.600 9.000 ;
      RECT 16.800 8.400 19.200 9.000 ;
      RECT 22.200 8.400 22.800 9.000 ;
      RECT 1.800 7.800 4.200 8.400 ;
      RECT 9.600 7.800 12.000 8.400 ;
      RECT 14.400 7.800 15.000 8.400 ;
      RECT 16.800 7.800 19.200 8.400 ;
      RECT 21.600 7.800 22.200 8.400 ;
      RECT 1.800 7.200 4.200 7.800 ;
      RECT 9.000 7.200 11.400 7.800 ;
      RECT 14.400 7.200 15.000 7.800 ;
      RECT 16.200 7.200 18.600 7.800 ;
      RECT 21.600 7.200 22.200 7.800 ;
      RECT 2.400 6.600 7.200 7.200 ;
      RECT 9.000 6.600 14.400 7.200 ;
      RECT 16.200 6.600 21.600 7.200 ;
      RECT 5.400 6.000 7.800 6.600 ;
      RECT 9.000 6.000 12.000 6.600 ;
      RECT 16.200 6.000 18.600 6.600 ;
      RECT 21.600 6.000 22.200 6.600 ;
      RECT 5.400 5.400 7.800 6.000 ;
      RECT 8.400 5.400 12.000 6.000 ;
      RECT 15.600 5.400 18.000 6.000 ;
      RECT 21.600 5.400 22.200 6.000 ;
      RECT 4.800 4.800 7.200 5.400 ;
      RECT 8.400 4.800 10.800 5.400 ;
      RECT 11.400 4.800 12.600 5.400 ;
      RECT 15.600 4.800 18.000 5.400 ;
      RECT 21.000 4.800 21.600 5.400 ;
      RECT 4.800 4.200 7.200 4.800 ;
      RECT 7.800 4.200 10.800 4.800 ;
      RECT 11.400 4.200 12.600 4.800 ;
      RECT 15.000 4.200 18.000 4.800 ;
      RECT 21.000 4.200 21.600 4.800 ;
      RECT 4.200 3.600 6.600 4.200 ;
      RECT 7.800 3.600 10.200 4.200 ;
      RECT 12.000 3.600 13.200 4.200 ;
      RECT 15.000 3.600 17.400 4.200 ;
      RECT 20.400 3.600 21.000 4.200 ;
      RECT 4.200 3.000 6.600 3.600 ;
      RECT 7.800 3.000 10.200 3.600 ;
      RECT 12.000 3.000 13.200 3.600 ;
      RECT 15.000 3.000 17.400 3.600 ;
      RECT 20.400 3.000 21.000 3.600 ;
      RECT 3.600 2.400 6.000 3.000 ;
      RECT 7.200 2.400 9.600 3.000 ;
      RECT 12.600 2.400 13.800 3.000 ;
      RECT 14.400 2.400 16.800 3.000 ;
      RECT 19.800 2.400 20.400 3.000 ;
      RECT 3.600 1.800 6.000 2.400 ;
      RECT 7.200 1.800 9.600 2.400 ;
      RECT 12.600 1.800 13.800 2.400 ;
      RECT 14.400 1.800 16.800 2.400 ;
      RECT 19.800 1.800 20.400 2.400 ;
      RECT 21.000 1.800 22.200 2.400 ;
      RECT 0.600 1.200 5.400 1.800 ;
      RECT 7.200 1.200 9.000 1.800 ;
      RECT 12.600 1.200 13.800 1.800 ;
      RECT 15.000 1.200 19.800 1.800 ;
      RECT 21.000 1.200 22.800 1.800 ;
      RECT 21.600 0.600 23.400 1.200 ;
      RECT 0.000 0.000 23.400 0.600 ;
      RECT 15.900 11.700 16.500 12.300 ;
      RECT 23.100 11.700 23.700 12.300 ;
      RECT 15.900 10.500 16.500 11.100 ;
      RECT 23.100 10.500 23.700 11.100 ;
      RECT 15.300 9.300 15.900 9.900 ;
      RECT 22.500 9.300 23.100 9.900 ;
      RECT 14.700 8.100 15.300 8.700 ;
      RECT 21.900 8.100 22.500 8.700 ;
      RECT 14.100 6.900 14.700 7.500 ;
      RECT 21.300 6.900 21.900 7.500 ;
      RECT 21.300 6.300 21.900 6.900 ;
      RECT 21.300 5.100 21.900 5.700 ;
      RECT 20.700 3.900 21.300 4.500 ;
      RECT 20.100 2.700 20.700 3.300 ;
      RECT 19.500 1.500 20.100 2.100 ;
  END
END CHIP_ART_initials

END LIBRARY
