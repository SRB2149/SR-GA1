VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS

MACRO CHIP_ART_logo
  CLASS BLOCK ;
  ORIGIN 0.000 0.000 ;
  FOREIGN CHIP_ART_logo 0.000 0.000 ;
  SIZE 39.000 BY 12.600 ;
  SYMMETRY X Y R90 ;
  OBS
    LAYER met4 ;
      RECT 4.200 12.000 9.000 12.600 ;
      RECT 11.400 12.000 16.200 12.600 ;
      RECT 22.800 12.000 27.600 12.600 ;
      RECT 30.000 12.000 35.400 12.600 ;
      RECT 37.200 12.000 39.000 12.600 ;
      RECT 3.600 11.400 6.000 12.000 ;
      RECT 10.800 11.400 13.200 12.000 ;
      RECT 16.200 11.400 16.800 12.000 ;
      RECT 22.200 11.400 24.600 12.000 ;
      RECT 31.800 11.400 32.400 12.000 ;
      RECT 37.200 11.400 39.000 12.000 ;
      RECT 3.600 10.800 6.000 11.400 ;
      RECT 10.800 10.800 13.200 11.400 ;
      RECT 16.200 10.800 16.800 11.400 ;
      RECT 22.200 10.800 24.600 11.400 ;
      RECT 29.400 10.800 30.000 11.400 ;
      RECT 31.200 10.800 31.800 11.400 ;
      RECT 33.000 10.800 33.600 11.400 ;
      RECT 36.600 10.800 38.400 11.400 ;
      RECT 3.000 10.200 5.400 10.800 ;
      RECT 10.200 10.200 12.600 10.800 ;
      RECT 15.600 10.200 16.200 10.800 ;
      RECT 21.600 10.200 24.000 10.800 ;
      RECT 28.800 10.200 29.400 10.800 ;
      RECT 30.000 10.200 30.600 10.800 ;
      RECT 31.200 10.200 31.800 10.800 ;
      RECT 32.400 10.200 33.000 10.800 ;
      RECT 33.600 10.200 34.200 10.800 ;
      RECT 36.600 10.200 38.400 10.800 ;
      RECT 3.000 9.600 5.400 10.200 ;
      RECT 10.200 9.600 12.600 10.200 ;
      RECT 15.600 9.600 16.200 10.200 ;
      RECT 21.600 9.600 24.000 10.200 ;
      RECT 28.800 9.600 29.400 10.200 ;
      RECT 30.000 9.600 30.600 10.200 ;
      RECT 31.200 9.600 31.800 10.200 ;
      RECT 32.400 9.600 33.000 10.200 ;
      RECT 33.600 9.600 34.200 10.200 ;
      RECT 36.600 9.600 38.400 10.200 ;
      RECT 2.400 9.000 4.800 9.600 ;
      RECT 9.600 9.000 12.600 9.600 ;
      RECT 15.000 9.000 15.600 9.600 ;
      RECT 21.000 9.000 24.000 9.600 ;
      RECT 28.800 9.000 30.600 9.600 ;
      RECT 31.200 9.000 31.800 9.600 ;
      RECT 32.400 9.000 34.200 9.600 ;
      RECT 36.000 9.000 37.800 9.600 ;
      RECT 2.400 8.400 4.800 9.000 ;
      RECT 9.600 8.400 12.000 9.000 ;
      RECT 15.000 8.400 15.600 9.000 ;
      RECT 21.000 8.400 23.400 9.000 ;
      RECT 28.800 8.400 29.400 9.000 ;
      RECT 30.000 8.400 30.600 9.000 ;
      RECT 31.200 8.400 31.800 9.000 ;
      RECT 32.400 8.400 33.000 9.000 ;
      RECT 33.600 8.400 34.200 9.000 ;
      RECT 36.000 8.400 37.800 9.000 ;
      RECT 1.800 7.800 4.200 8.400 ;
      RECT 9.600 7.800 12.000 8.400 ;
      RECT 14.400 7.800 15.000 8.400 ;
      RECT 21.000 7.800 23.400 8.400 ;
      RECT 28.800 7.800 29.400 8.400 ;
      RECT 30.000 7.800 30.600 8.400 ;
      RECT 31.200 7.800 31.800 8.400 ;
      RECT 32.400 7.800 33.000 8.400 ;
      RECT 33.600 7.800 34.200 8.400 ;
      RECT 36.000 7.800 37.800 8.400 ;
      RECT 1.800 7.200 4.200 7.800 ;
      RECT 9.000 7.200 11.400 7.800 ;
      RECT 14.400 7.200 15.000 7.800 ;
      RECT 16.800 7.200 19.200 7.800 ;
      RECT 20.400 7.200 22.800 7.800 ;
      RECT 31.200 7.200 31.800 7.800 ;
      RECT 35.400 7.200 37.200 7.800 ;
      RECT 2.400 6.600 7.200 7.200 ;
      RECT 9.000 6.600 14.400 7.200 ;
      RECT 16.200 6.600 18.600 7.200 ;
      RECT 20.400 6.600 22.800 7.200 ;
      RECT 24.000 6.600 25.800 7.200 ;
      RECT 27.600 6.600 33.600 7.200 ;
      RECT 35.400 6.600 37.200 7.200 ;
      RECT 5.400 6.000 7.800 6.600 ;
      RECT 9.000 6.000 12.000 6.600 ;
      RECT 15.600 6.000 18.000 6.600 ;
      RECT 20.400 6.000 22.800 6.600 ;
      RECT 25.200 6.000 26.400 6.600 ;
      RECT 30.000 6.000 30.600 6.600 ;
      RECT 35.400 6.000 37.200 6.600 ;
      RECT 5.400 5.400 7.800 6.000 ;
      RECT 8.400 5.400 12.000 6.000 ;
      RECT 19.800 5.400 22.200 6.000 ;
      RECT 25.200 5.400 26.400 6.000 ;
      RECT 27.600 5.400 28.200 6.000 ;
      RECT 29.400 5.400 30.000 6.000 ;
      RECT 31.200 5.400 31.800 6.000 ;
      RECT 34.800 5.400 36.600 6.000 ;
      RECT 4.800 4.800 7.200 5.400 ;
      RECT 8.400 4.800 10.800 5.400 ;
      RECT 11.400 4.800 12.600 5.400 ;
      RECT 19.800 4.800 22.200 5.400 ;
      RECT 24.600 4.800 25.800 5.400 ;
      RECT 27.000 4.800 27.600 5.400 ;
      RECT 28.200 4.800 28.800 5.400 ;
      RECT 29.400 4.800 30.000 5.400 ;
      RECT 30.600 4.800 31.200 5.400 ;
      RECT 31.800 4.800 32.400 5.400 ;
      RECT 34.800 4.800 36.600 5.400 ;
      RECT 4.800 4.200 7.200 4.800 ;
      RECT 7.800 4.200 10.800 4.800 ;
      RECT 11.400 4.200 12.600 4.800 ;
      RECT 19.200 4.200 22.200 4.800 ;
      RECT 24.600 4.200 25.800 4.800 ;
      RECT 27.000 4.200 27.600 4.800 ;
      RECT 28.200 4.200 28.800 4.800 ;
      RECT 29.400 4.200 30.000 4.800 ;
      RECT 30.600 4.200 31.200 4.800 ;
      RECT 31.800 4.200 32.400 4.800 ;
      RECT 34.800 4.200 36.600 4.800 ;
      RECT 4.200 3.600 6.600 4.200 ;
      RECT 7.800 3.600 10.200 4.200 ;
      RECT 12.000 3.600 13.200 4.200 ;
      RECT 19.200 3.600 21.600 4.200 ;
      RECT 24.000 3.600 25.200 4.200 ;
      RECT 27.000 3.600 28.800 4.200 ;
      RECT 29.400 3.600 30.000 4.200 ;
      RECT 30.600 3.600 32.400 4.200 ;
      RECT 34.200 3.600 36.000 4.200 ;
      RECT 4.200 3.000 6.600 3.600 ;
      RECT 7.800 3.000 10.200 3.600 ;
      RECT 12.000 3.000 13.200 3.600 ;
      RECT 19.200 3.000 21.600 3.600 ;
      RECT 24.000 3.000 25.200 3.600 ;
      RECT 27.000 3.000 27.600 3.600 ;
      RECT 28.200 3.000 28.800 3.600 ;
      RECT 29.400 3.000 30.000 3.600 ;
      RECT 30.600 3.000 31.200 3.600 ;
      RECT 31.800 3.000 32.400 3.600 ;
      RECT 34.200 3.000 36.000 3.600 ;
      RECT 3.600 2.400 6.000 3.000 ;
      RECT 7.200 2.400 9.600 3.000 ;
      RECT 12.600 2.400 13.800 3.000 ;
      RECT 18.600 2.400 21.000 3.000 ;
      RECT 23.400 2.400 24.600 3.000 ;
      RECT 27.000 2.400 27.600 3.000 ;
      RECT 28.200 2.400 28.800 3.000 ;
      RECT 29.400 2.400 30.000 3.000 ;
      RECT 30.600 2.400 31.200 3.000 ;
      RECT 31.800 2.400 32.400 3.000 ;
      RECT 34.200 2.400 36.000 3.000 ;
      RECT 3.600 1.800 6.000 2.400 ;
      RECT 7.200 1.800 9.600 2.400 ;
      RECT 12.600 1.800 13.800 2.400 ;
      RECT 18.600 1.800 21.000 2.400 ;
      RECT 23.400 1.800 24.600 2.400 ;
      RECT 29.400 1.800 30.000 2.400 ;
      RECT 33.600 1.800 35.400 2.400 ;
      RECT 36.600 1.800 37.800 2.400 ;
      RECT 0.600 1.200 5.400 1.800 ;
      RECT 7.200 1.200 9.000 1.800 ;
      RECT 12.600 1.200 13.800 1.800 ;
      RECT 19.200 1.200 24.000 1.800 ;
      RECT 26.400 1.200 31.800 1.800 ;
      RECT 33.600 1.200 35.400 1.800 ;
      RECT 36.600 1.200 38.400 1.800 ;
      RECT 37.200 0.600 39.000 1.200 ;
      RECT 0.000 0.000 39.000 0.600 ;
      RECT 15.900 11.700 16.500 12.300 ;
      RECT 31.500 11.100 32.100 11.700 ;
      RECT 15.900 10.500 16.500 11.100 ;
      RECT 29.100 10.500 29.700 11.100 ;
      RECT 29.700 10.500 30.300 11.100 ;
      RECT 32.700 10.500 33.300 11.100 ;
      RECT 33.300 10.500 33.900 11.100 ;
      RECT 15.300 9.300 15.900 9.900 ;
      RECT 14.700 8.100 15.300 8.700 ;
      RECT 14.100 6.900 14.700 7.500 ;
      RECT 29.700 5.700 30.300 6.300 ;
      RECT 27.300 5.100 27.900 5.700 ;
      RECT 27.900 5.100 28.500 5.700 ;
      RECT 30.900 5.100 31.500 5.700 ;
      RECT 31.500 5.100 32.100 5.700 ;
  END
END CHIP_ART_logo

END LIBRARY
